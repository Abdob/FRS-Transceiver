<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bladeRF_frs</value></param>
<param><key>author</key><value>Nuand, LLC &lt;bladeRF@nuand.com&gt;</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Multi-channel FRS transceiver with CTCSS.  A USB 3.0 connection is required for full-duplex operation.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FRS Transceiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ctcss_enable</value></param>
<param><key>value</key><value>(ctcss_freq != 0)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ctcss_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0, 0</value></param>
<param><key>label</key><value>CTCSS</value></param>
<param><key>labels</key><value>["None", "1", "2", "3", "4", "5", "6", "7", "8", "9", "10", "11", "12", "13", "14", "15", "16", "17", "18", "19", "20", "21", "22", "23", "24", "25", "26", "27", "28", "29", "30", "31", "32", "33", "34", "35", "36", "37", "38"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 67.0,  71.9,  74.4,  77.0,  79.7,  82.5,  85.4,  88.5,  91.5,  94.8, 97.4, 100.0, 103.5, 107.2, 110.9, 114.8, 118.8, 123.0, 127.3, 131.8, 136.5, 141.3, 146.2, 151.4, 156.7, 162.2, 167.9, 173.8, 179.9, 186.2, 192.8, 203.5, 210.7, 218.1, 225.7, 233.6, 241.8, 250.3]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>value</key><value>[1,-5.6992016578761877099168486893177032470703125,13.56101351514487163285593851469457149505615234375,-17.24510428469104539317413582466542720794677734375,12.3620564992096202416860251105390489101409912109375,-4.7368104535795811926845999551005661487579345703125,0.7580490211161876601408948772586882114410400390625]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>value</key><value>[0.77275029037678344412398701024358160793781280517578125,-4.62934886736234840753922981093637645244598388671875,11.562660778112377357729201321490108966827392578125,-15.4121243939073497841718562995083630084991455078125,11.562660778112377357729201321490108966827392578125,-4.62934886736234840753922981093637645244598388671875,0.77275029037678344412398701024358160793781280517578125]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbfm_tau</value></param>
<param><key>value</key><value>5e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_rx_freq</value></param>
<param><key>value</key><value>2.1e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_audio_sample_rate</value></param>
<param><key>value</key><value>int(25e3)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch10_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 10, 1, 1</value></param>
<param><key>label</key><value>10</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch11_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 11, 1, 1</value></param>
<param><key>label</key><value>11</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_ch11_offset</value></param>
<param><key>value</key><value>467.6375e6 - rf_rx_freq</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch12_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 12, 1, 1</value></param>
<param><key>label</key><value>12</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch13_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 13, 1, 1</value></param>
<param><key>label</key><value>13</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch14_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 14, 1, 1</value></param>
<param><key>label</key><value>14</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch1_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 1, 1, 1</value></param>
<param><key>label</key><value>1</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch2_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 2, 1, 1</value></param>
<param><key>label</key><value>2</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch3_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 3, 1, 1</value></param>
<param><key>label</key><value>3</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch4_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 4, 1, 1</value></param>
<param><key>label</key><value>4</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_ch4_offset</value></param>
<param><key>value</key><value>462.6375e6 - rf_rx_freq</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch5_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 5, 1, 1</value></param>
<param><key>label</key><value>5</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch6_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 6, 1, 1</value></param>
<param><key>label</key><value>6</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch7_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 7, 1, 1</value></param>
<param><key>label</key><value>7</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch8_enable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 8, 1, 1</value></param>
<param><key>label</key><value>8</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_ch9_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 9, 1, 1</value></param>
<param><key>label</key><value>9</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rx_ch_label</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>tabs@0: 0, 0, 1, 1</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_ctcss_len</value></param>
<param><key>value</key><value>int(0.250 * rx_audio_sample_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_ctcss_squelch</value></param>
<param><key>value</key><value>0.010</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_dec_fir_taps</value></param>
<param><key>value</key><value>[-1.0662e-05,6.8043e-06,2.4381e-05,5.1631e-05,8.2064e-05,0.00010369,0.00010047,5.6519e-05,-3.757e-05,-0.00017776,-0.00034135,-0.00048602,-0.00055545,-0.00049196,-0.00025471,0.00016054,0.00070578,0.0012759,0.0017192,0.001866,0.001571,0.00076303,-0.00051222,-0.0020683,-0.0035871,-0.0046655,-0.0048987,-0.003985,-0.0018318,0.0013662,0.0051016,0.0086021,0.010954,0.011289,0.0090026,0.0039584,-0.0033701,-0.011863,-0.019851,-0.025341,-0.026348,-0.021276,-0.0092719,0.0095133,0.033821,0.061376,0.089168,0.11388,0.1324,0.14232,0.14232,0.1324,0.11388,0.089168,0.061376,0.033821,0.0095133,-0.0092719,-0.021276,-0.026348,-0.025341,-0.019851,-0.011863,-0.0033701,0.0039584,0.0090026,0.011289,0.010954,0.0086021,0.0051016,0.0013662,-0.0018318,-0.003985,-0.0048987,-0.0046655,-0.0035871,-0.0020683,-0.00051222,0.00076303,0.001571,0.001866,0.0017192,0.0012759,0.00070578,0.00016054,-0.00025471,-0.00049196,-0.00055545,-0.00048602,-0.00034135,-0.00017776,-3.757e-05,5.6519e-05,0.00010047,0.00010369,8.2064e-05,5.1631e-05,2.4381e-05,6.8043e-06,-1.0662e-05]</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>rx_enable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0, 1</value></param>
<param><key>label</key><value>Enable RX</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rx_lna_gain</value></param>
<param><key>value</key><value>6</value></param>
<param><key>gui_hint</key><value>tabs@0: 1, 0, 1, 1</value></param>
<param><key>label0</key><value>0 dB</value></param>
<param><key>label1</key><value>3 dB</value></param>
<param><key>label2</key><value>6  dB</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>3</value></param>
<param><key>option2</key><value>6</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_pc_taps</value></param>
<param><key>value</key><value>[-0.00045208,-4.474e-05,-4.0307e-05,-3.0817e-05,-1.6342e-05,3.4432e-06,2.8181e-05,5.7893e-05,9.1868e-05,0.00012974,0.0001704,0.00021304,0.00025609,0.00029836,0.00033796,0.00037353,0.00040315,0.00042547,0.00043837,0.00043955,0.00042895,0.00040433,0.0003649,0.00031024,0.00023988,0.00015429,5.3909e-05,-5.9804e-05,-0.00018539,-0.00032035,-0.00046214,-0.00060725,-0.00075225,-0.00089289,-0.0010252,-0.0011443,-0.0012459,-0.0013251,-0.0013782,-0.0014005,-0.001389,-0.0013403,-0.0012525,-0.0011239,-0.00095447,-0.0007445,-0.000496,-0.00021167,0.00010412,0.00044629,0.00080818,0.0011825,0.0015606,0.0019335,0.0022909,0.0026229,0.0029187,0.0031679,0.0033603,0.0034864,0.0035374,0.0035059,0.0033856,0.0031722,0.002863,0.0024579,0.0019586,0.0013694,0.00069708,-4.8959e-05,-0.00085709,-0.001713,-0.0026004,-0.0035007,-0.0043939,-0.005258,-0.0060704,-0.0068075,-0.0074456,-0.007961,-0.008331,-0.0085338,-0.0085494,-0.0083598,-0.0079499,-0.0073073,-0.0064233,-0.0052925,-0.0039139,-0.0022905,-0.00042946,0.0016577,0.0039549,0.0064425,0.0090964,0.011889,0.01479,0.017766,0.020781,0.023798,0.026777,0.029681,0.03247,0.035106,0.037553,0.039777,0.041747,0.043433,0.044813,0.045865,0.046576,0.046933,0.046933,0.046576,0.045865,0.044813,0.043433,0.041747,0.039777,0.037553,0.035106,0.03247,0.029681,0.026777,0.023798,0.020781,0.017766,0.01479,0.011889,0.0090964,0.0064425,0.0039549,0.0016577,-0.00042946,-0.0022905,-0.0039139,-0.0052925,-0.0064233,-0.0073073,-0.0079499,-0.0083598,-0.0085494,-0.0085338,-0.008331,-0.007961,-0.0074456,-0.0068075,-0.0060704,-0.005258,-0.0043939,-0.0035007,-0.0026004,-0.001713,-0.00085709,-4.8959e-05,0.00069708,0.0013694,0.0019586,0.0024579,0.002863,0.0031722,0.0033856,0.0035059,0.0035374,0.0034864,0.0033603,0.0031679,0.0029187,0.0026229,0.0022909,0.0019335,0.0015606,0.0011825,0.00080818,0.00044629,0.00010412,-0.00021167,-0.000496,-0.0007445,-0.00095447,-0.0011239,-0.0012525,-0.0013403,-0.001389,-0.0014005,-0.0013782,-0.0013251,-0.0012459,-0.0011443,-0.0010252,-0.00089289,-0.00075225,-0.00060725,-0.00046214,-0.00032035,-0.00018539,-5.9804e-05,5.3909e-05,0.00015429,0.00023988,0.00031024,0.0003649,0.00040433,0.00042895,0.00043955,0.00043837,0.00042547,0.00040315,0.00037353,0.00033796,0.00029836,0.00025609,0.00021304,0.0001704,0.00012974,9.1868e-05,5.7893e-05,2.8181e-05,3.4432e-06,-1.6342e-05,-3.0817e-05,-4.0307e-05,-4.474e-05,-0.00045208]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_power_squelch_alpha</value></param>
<param><key>value</key><value>0.0125</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_rf_sample_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_squelch</value></param>
<param><key>value</key><value>-45</value></param>
<param><key>gui_hint</key><value>tabs@0: 1, 5, 1, 4</value></param>
<param><key>label</key><value>Power Squelch (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_vga_gain</value></param>
<param><key>value</key><value>33</value></param>
<param><key>gui_hint</key><value>tabs@0: 1, 1, 1, 4</value></param>
<param><key>label</key><value>RX VGA1+VGA2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_xlating_fir_taps</value></param>
<param><key>value</key><value>[-4.7805e-05,-0.00019404,-0.00053601,-0.0011824,-0.0022208,-0.0036578,-0.0053495,-0.0069408,-0.0078402,-0.0072531,-0.0042895,0.001863,0.011725,0.025321,0.042041,0.060612,0.079218,0.095753,0.10816,0.11482,0.11482,0.10816,0.095753,0.079218,0.060612,0.042041,0.025321,0.011725,0.001863,-0.0042895,-0.0072531,-0.0078402,-0.0069408,-0.0053495,-0.0036578,-0.0022208,-0.0011824,-0.00053601,-0.00019404,-4.7805e-05]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_audio_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tabs@1: 1, 0, 1, 5</value></param>
<param><key>label</key><value>Audio Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0125</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch10_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 10, 1, 1</value></param>
<param><key>label</key><value>10</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch11_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 11, 1, 1</value></param>
<param><key>label</key><value>11</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch12_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 12, 1, 1</value></param>
<param><key>label</key><value>12</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch13_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 13, 1, 1</value></param>
<param><key>label</key><value>13</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch14_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 14, 1, 1</value></param>
<param><key>label</key><value>14</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch1_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 1, 1, 1</value></param>
<param><key>label</key><value>1</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch2_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 2, 1, 1</value></param>
<param><key>label</key><value>2</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch3_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 3, 1, 1</value></param>
<param><key>label</key><value>3</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch4_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 4, 1, 1</value></param>
<param><key>label</key><value>4</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch5_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 5, 1, 1</value></param>
<param><key>label</key><value>5</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch6_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 6, 1, 1</value></param>
<param><key>label</key><value>6</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch7_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 7, 1, 1</value></param>
<param><key>label</key><value>7</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch8_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 8, 1, 1</value></param>
<param><key>label</key><value>8</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_ch9_enable</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 9, 1, 1</value></param>
<param><key>label</key><value>9</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tx_ch_label</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>tabs@1: 0, 0, 1, 1</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>tx_cont</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0, 2</value></param>
<param><key>label</key><value>Continuous TX</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_num_enabled_ch1_7</value></param>
<param><key>value</key><value>sum([tx_ch1_enable, tx_ch2_enable, tx_ch3_enable, tx_ch4_enable, tx_ch5_enable, tx_ch6_enable, tx_ch7_enable])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_num_enabled_ch8_14</value></param>
<param><key>value</key><value>sum([tx_ch8_enable, tx_ch9_enable, tx_ch10_enable, tx_ch11_enable, tx_ch12_enable, tx_ch13_enable, tx_ch14_enable])</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tx_ptt</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>0, 3</value></param>
<param><key>label</key><value>Push to Talk</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_vga1_gain</value></param>
<param><key>value</key><value>-8</value></param>
<param><key>gui_hint</key><value>tabs@1: 1, 5, 1, 5</value></param>
<param><key>label</key><value>VGA1 Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-35</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_vga2_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tabs@1: 1, 10, 1, 5</value></param>
<param><key>label</key><value>VGA2 Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>bladerf_single_rx</key>
<param><key>id</key><value>bladerf_single_rx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>bladerf_single_rx</key>
<param><key>id</key><value>bladerf_single_rx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/foci2/Documents/sdr/gnuradio/gr-osmosdr/build/C:\Users\Jevin\Documents\AltRx.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/sdr/FRS-Transceiver/GRC/dual_RX_2_alt.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(rx_rf_sample_rate / 30)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0</value></param>
<param><key>bus_conns</key><value>[[0,1,2,3,4,5,6,7,8,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>9</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0_0</value></param>
<param><key>bus_conns</key><value>[[0,1,2,3,4,5,6,7,8,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>9</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>rx_rf_sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch10_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch11_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch12_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch13_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch14_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch1_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>ch1_note</value></param>
<param><key>note</key><value>Channel 1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch2_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch3_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch4_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch5_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch6_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch7_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>ch7_note</value></param>
<param><key>note</key><value>Channel 7</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch8_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>ch9_audio_sel</value></param>
<param><key>input_index</key><value>0 if ctcss_enable else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>ch_14_note</value></param>
<param><key>note</key><value>Channel 14</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>ch_1_7_note</value></param>
<param><key>note</key><value>Channels 1 - 7</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>ch_8_14_note</value></param>
<param><key>note</key><value>Channels 8 - 14</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>ch_8_note</value></param>
<param><key>note</key><value>Channel 8</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>rx_dec_fir_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>rx_dec_fir_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>rx_ch4_offset</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>samp_rate</key><value>rx_rf_sample_rate</value></param>
<param><key>taps</key><value>rx_xlating_fir_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>2.3e6</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>samp_rate</key><value>rx_rf_sample_rate</value></param>
<param><key>taps</key><value>rx_xlating_fir_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>6e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>rf_rx_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value>bladerf=0,bladerf=0,buffers=32,buflen=4096,stream_timeout=10000,transfers=16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rx_rf_sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>6e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2.1e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>bw1</key><value>6e6</value></param>
<param><key>dc_offset_mode1</key><value>1</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>2.1e9</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>iq_balance_mode1</key><value>1</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>args</key><value>bladerf=0,buffers=32,buflen=4096,stream_timeout=1000,transfers=16,nchan=2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rx_rf_sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ch1_ch17</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0], [1], [2], [3], [4], [5], [6], [7, 8, 9, 10, 11, 12, 13, 14, 15]]</value></param>
<param><key>ch_map</key><value>[13, 14, 15, 0, 1, 2, 3]</value></param>
<param><key>nchans</key><value>16</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>taps</key><value>rx_pc_taps</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ch8_ch14</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0], [1], [2], [3], [4], [5], [6], [7, 8, 9, 10, 11, 12, 13, 14, 15]]</value></param>
<param><key>ch_map</key><value>[13, 14, 15, 0, 1, 2, 3]</value></param>
<param><key>nchans</key><value>16</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>taps</key><value>rx_pc_taps</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>tabs@0:3,8,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>"     Input Power     "</value></param>
<param><key>unit1</key><value>dBFS</value></param>
<param><key>max</key><value>3</value></param>
<param><key>min</key><value>-50</value></param>
<param><key>name</key><value></value></param>
<param><key>update_time</key><value>1 / 30.0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>rx_rf_sample_rate / 20</value></param>
<param><key>fc</key><value>rf_rx_freq + rx_ch4_offset</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0: 3, 0, 2, 8</value></param>
<param><key>name</key><value>Channels 1-7</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>rx_rf_sample_rate / 20</value></param>
<param><key>fc</key><value>rf_rx_freq + rx_ch11_offset</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0: 3, 9, 2, 8</value></param>
<param><key>name</key><value>Channels 8-14</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch10_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch10_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch10_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch10_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch10_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch10_valve</value></param>
<param><key>open</key><value>not rx_ch10_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch11_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch11_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch11_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch11_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch11_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch11_valve</value></param>
<param><key>open</key><value>not rx_ch11_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch12_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch12_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch12_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch12_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch12_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch12_valve</value></param>
<param><key>open</key><value>not rx_ch12_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch13_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch13_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch13_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch13_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch13_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch13_valve</value></param>
<param><key>open</key><value>not rx_ch13_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch14_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch14_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch14_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch14_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch14_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch14_valve</value></param>
<param><key>open</key><value>not rx_ch14_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch1_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch1_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch1_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch1_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch1_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch1_valve</value></param>
<param><key>open</key><value>not rx_ch1_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch2_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch2_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch2_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch2_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch2_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch2_valve</value></param>
<param><key>open</key><value>not rx_ch2_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch3_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch3_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch3_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch3_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch3_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch3_valve</value></param>
<param><key>open</key><value>not rx_ch3_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch4_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch4_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch4_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch4_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch4_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch4_valve</value></param>
<param><key>open</key><value>not rx_ch4_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch5_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch5_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch5_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch5_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch5_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch5_valve</value></param>
<param><key>open</key><value>not rx_ch5_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch6_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch6_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch6_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch6_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch6_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch6_valve</value></param>
<param><key>open</key><value>not rx_ch6_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch7_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch7_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch7_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch7_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch7_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch7_valve</value></param>
<param><key>open</key><value>not rx_ch7_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch8_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch8_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch8_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch8_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch8_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch8_valve</value></param>
<param><key>open</key><value>not rx_ch8_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>rx_ch9_analog_ctcss_squelch_ff</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>rx_ctcss_len</value></param>
<param><key>level</key><value>rx_ctcss_squelch</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>rx_audio_sample_rate</value></param>
<param><key>freq</key><value>ctcss_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>rx_ch9_analog_pwr_squelch</value></param>
<param><key>alpha</key><value>rx_power_squelch_alpha</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>rx_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>rx_ch9_audio_sink</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>rx_audio_sample_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>rx_ch9_hpf_iir</value></param>
<param><key>fftaps</key><value>ctcss_hpf_ff_taps</value></param>
<param><key>fbtaps</key><value>ctcss_hpf_fb_taps</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>rx_ch9_nbfm</value></param>
<param><key>audio_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>rx_audio_sample_rate</value></param>
<param><key>tau</key><value>nbfm_tau</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_ch9_valve</value></param>
<param><key>open</key><value>not rx_ch9_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_enable_valve</value></param>
<param><key>open</key><value>not rx_enable</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.05</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>gui_hint</key><value>1, 0, 6, 16</value></param>
<param><key>label0</key><value>RX</value></param>
<param><key>label1</key><value>TX</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>bladerf_single_rx_0</source_block_id><sink_block_id>rx_enable_valve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bladerf_single_rx_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rx_enable_valve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch10_audio_sel</source_block_id><sink_block_id>rx_ch10_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch11_audio_sel</source_block_id><sink_block_id>rx_ch11_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch12_audio_sel</source_block_id><sink_block_id>rx_ch12_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch13_audio_sel</source_block_id><sink_block_id>rx_ch13_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch14_audio_sel</source_block_id><sink_block_id>rx_ch14_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch1_audio_sel</source_block_id><sink_block_id>rx_ch1_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch2_audio_sel</source_block_id><sink_block_id>rx_ch2_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch3_audio_sel</source_block_id><sink_block_id>rx_ch3_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch4_audio_sel</source_block_id><sink_block_id>rx_ch4_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch5_audio_sel</source_block_id><sink_block_id>rx_ch5_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch6_audio_sel</source_block_id><sink_block_id>rx_ch6_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch7_audio_sel</source_block_id><sink_block_id>rx_ch7_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch8_audio_sel</source_block_id><sink_block_id>rx_ch8_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ch9_audio_sel</source_block_id><sink_block_id>rx_ch9_hpf_iir</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>pfb_channelizer_ch1_ch17</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>pfb_channelizer_ch8_ch14</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rx_enable_valve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>rx_enable_valve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch1_valve</sink_block_id><source_key>16</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch2_valve</sink_block_id><source_key>17</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch3_valve</sink_block_id><source_key>18</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch4_valve</sink_block_id><source_key>19</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch5_valve</sink_block_id><source_key>20</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch6_valve</sink_block_id><source_key>21</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch7_valve</sink_block_id><source_key>22</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>23</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch1_valve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch2_valve</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>10</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>11</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>12</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>13</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>14</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>15</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch3_valve</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch4_valve</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch5_valve</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch6_valve</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>rx_ch7_valve</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>8</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch1_ch17</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>9</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch8_valve</sink_block_id><source_key>16</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch9_valve</sink_block_id><source_key>17</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch10_valve</sink_block_id><source_key>18</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch11_valve</sink_block_id><source_key>19</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch12_valve</sink_block_id><source_key>20</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch13_valve</sink_block_id><source_key>21</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch14_valve</sink_block_id><source_key>22</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>23</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch8_valve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch9_valve</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>10</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>11</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>12</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>13</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>14</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>15</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch10_valve</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch11_valve</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch12_valve</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch13_valve</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>rx_ch14_valve</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>8</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ch8_ch14</source_block_id><sink_block_id>blocks_null_sink_0_1_0_0</sink_block_id><source_key>9</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rx_ch10_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch10_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch10_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch10_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch10_hpf_iir</source_block_id><sink_block_id>rx_ch10_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch10_nbfm</source_block_id><sink_block_id>ch10_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch10_nbfm</source_block_id><sink_block_id>rx_ch10_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch10_valve</source_block_id><sink_block_id>rx_ch10_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch11_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch11_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch11_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch11_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch11_hpf_iir</source_block_id><sink_block_id>rx_ch11_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch11_nbfm</source_block_id><sink_block_id>ch11_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch11_nbfm</source_block_id><sink_block_id>rx_ch11_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch11_valve</source_block_id><sink_block_id>rx_ch11_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch12_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch12_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch12_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch12_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch12_hpf_iir</source_block_id><sink_block_id>rx_ch12_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch12_nbfm</source_block_id><sink_block_id>ch12_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch12_nbfm</source_block_id><sink_block_id>rx_ch12_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch12_valve</source_block_id><sink_block_id>rx_ch12_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch13_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch13_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch13_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch13_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch13_hpf_iir</source_block_id><sink_block_id>rx_ch13_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch13_nbfm</source_block_id><sink_block_id>ch13_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch13_nbfm</source_block_id><sink_block_id>rx_ch13_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch13_valve</source_block_id><sink_block_id>rx_ch13_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch14_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch14_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch14_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch14_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch14_hpf_iir</source_block_id><sink_block_id>rx_ch14_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch14_nbfm</source_block_id><sink_block_id>ch14_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch14_nbfm</source_block_id><sink_block_id>rx_ch14_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch14_valve</source_block_id><sink_block_id>rx_ch14_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch1_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch1_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch1_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch1_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch1_hpf_iir</source_block_id><sink_block_id>rx_ch1_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch1_nbfm</source_block_id><sink_block_id>ch1_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch1_nbfm</source_block_id><sink_block_id>rx_ch1_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch1_valve</source_block_id><sink_block_id>rx_ch1_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch2_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch2_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch2_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch2_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch2_hpf_iir</source_block_id><sink_block_id>rx_ch2_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch2_nbfm</source_block_id><sink_block_id>ch2_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch2_nbfm</source_block_id><sink_block_id>rx_ch2_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch2_valve</source_block_id><sink_block_id>rx_ch2_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch3_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch3_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch3_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch3_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch3_hpf_iir</source_block_id><sink_block_id>rx_ch3_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch3_nbfm</source_block_id><sink_block_id>ch3_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch3_nbfm</source_block_id><sink_block_id>rx_ch3_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch3_valve</source_block_id><sink_block_id>rx_ch3_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch4_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch4_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch4_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch4_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch4_hpf_iir</source_block_id><sink_block_id>rx_ch4_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch4_nbfm</source_block_id><sink_block_id>ch4_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch4_nbfm</source_block_id><sink_block_id>rx_ch4_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch4_valve</source_block_id><sink_block_id>rx_ch4_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch5_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch5_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch5_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch5_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch5_hpf_iir</source_block_id><sink_block_id>rx_ch5_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch5_nbfm</source_block_id><sink_block_id>ch5_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch5_nbfm</source_block_id><sink_block_id>rx_ch5_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch5_valve</source_block_id><sink_block_id>rx_ch5_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch6_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch6_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch6_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch6_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch6_hpf_iir</source_block_id><sink_block_id>rx_ch6_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch6_nbfm</source_block_id><sink_block_id>ch6_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch6_nbfm</source_block_id><sink_block_id>rx_ch6_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch6_valve</source_block_id><sink_block_id>rx_ch6_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch7_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch7_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch7_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch7_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch7_hpf_iir</source_block_id><sink_block_id>rx_ch7_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch7_nbfm</source_block_id><sink_block_id>ch7_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch7_nbfm</source_block_id><sink_block_id>rx_ch7_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch7_valve</source_block_id><sink_block_id>rx_ch7_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch8_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch8_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch8_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch8_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch8_hpf_iir</source_block_id><sink_block_id>rx_ch8_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch8_nbfm</source_block_id><sink_block_id>ch8_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch8_nbfm</source_block_id><sink_block_id>rx_ch8_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch8_valve</source_block_id><sink_block_id>rx_ch8_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch9_analog_ctcss_squelch_ff</source_block_id><sink_block_id>ch9_audio_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch9_analog_pwr_squelch</source_block_id><sink_block_id>rx_ch9_nbfm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch9_hpf_iir</source_block_id><sink_block_id>rx_ch9_audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch9_nbfm</source_block_id><sink_block_id>ch9_audio_sel</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_ch9_nbfm</source_block_id><sink_block_id>rx_ch9_analog_ctcss_squelch_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_ch9_valve</source_block_id><sink_block_id>rx_ch9_analog_pwr_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_enable_valve</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_enable_valve</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_enable_valve</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
