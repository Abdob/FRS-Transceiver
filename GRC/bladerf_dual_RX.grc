<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>rx1.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>rx2.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>.5e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2.4e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>bb_gain1</key><value>0</value></param>
<param><key>bw1</key><value>.5e6</value></param>
<param><key>dc_offset_mode1</key><value>1</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>2.4e9</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>0</value></param>
<param><key>iq_balance_mode1</key><value>1</value></param>
<param><key>gain1</key><value>30</value></param>
<param><key>args</key><value>bladerf=0,nchan=2,agc_mode=manual,enable_metadata=1,verbosity=debug</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192*1</value></param>
<param><key>label1</key><value>RX1</value></param>
<param><key>label2</key><value>RX2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>RX1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0</value></param>
<param><key>stream_id</key><value>RX2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>stream_id</key><value>RX2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0</value></param>
<param><key>stream_id</key><value>RX1</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
